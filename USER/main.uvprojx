# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\MyCode\led;..\MyCode\temper;..\MyCode\TIMER;..\MyCode\gsm;..\MyCode\uart;..\MyCode\mp3;..\MyCode\step;..\MyCode\lcd1602;..\MyCode\ds18b20;..\MyCode\at24c02;..\MyCode\key;..\MyCode\us100;..\MyCode\RTC;..\MyCode\paj7620u2;..\MyCode\timer_pwm;..\MyCode\seg4module;..\MyCode\mhz19b;..\MyCode\adc;..\MyCode\esp8266;..\MyCode\hx711;..\MyCode\ml90614;..\MyCode\12864;..\MyCode\gps;..\MyCode\sled
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group MyCode
    ../MyCode/led/: LED.c
    ../MyCode/TIMER/: timer.c
    ../MyCode/key/: key.c
    ../MyCode/sled/: sled.c
    ../MyCode/ds18b20/: ds18b20.c
    ../MyCode/timer_pwm/: timer_pwm.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_exti.c
    ../CORE/: core_cm3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
